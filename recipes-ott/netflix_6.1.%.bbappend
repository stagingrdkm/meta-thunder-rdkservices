NFX_BINPKG_THUNDER4 = "20230802181328"

