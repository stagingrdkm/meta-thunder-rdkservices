# binary package timestamp for builds with Thunder4 (R4.3)
IGNITION_BINPKG_THUNDER4 = "20230829141251"
