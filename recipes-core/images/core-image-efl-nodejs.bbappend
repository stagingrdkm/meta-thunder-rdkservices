IMAGE_INSTALL += "packagegroup-thunder-base-rdkservices"
