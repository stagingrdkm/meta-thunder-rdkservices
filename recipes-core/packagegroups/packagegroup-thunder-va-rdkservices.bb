SUMMARY = "additional/all rdkservices added by RDKM Video Accelerator"
inherit packagegroup

PACKAGES = "packagegroup-thunder-comcast-rdkservices"

#empty list now
#RDEPENDS_${PN} += "rdkservice-todo"
