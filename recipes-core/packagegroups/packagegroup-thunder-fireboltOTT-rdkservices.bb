SUMMARY = "additional firebolt services used by the TOP tier Premium OTT apps, indentified during Netflix6.x, Cobalt23, AVPKv5, Disney+3 porting"
inherit packagegroup

PACKAGES = "packagegroup-thunder-fireboltOTT-rdkservices"

#empty list now
#RDEPENDS_${PN} += "rdkservice-todo"