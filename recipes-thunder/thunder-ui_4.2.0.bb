# R4.2 of ThunderUI project equal to R4.3
SRCREV = "aa8c9287cc34753d66eb9a2fd4c114d7dda78a19"

# Comcast use here:
#Version on July 22, 2021
#SRCREV = "ae6d061a6a08d97ad3ad8821c422b4f45aeeced1"
# lack of MessageControl toggle on/of log messages functionality

