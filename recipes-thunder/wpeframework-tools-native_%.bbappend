# # R4.1 tag version
SRCREV_thunder = "65bff2a6c5599ccbeb01d77a16417ad9d09df918"
RDEPENDS_${PN}_remove = "python3"

